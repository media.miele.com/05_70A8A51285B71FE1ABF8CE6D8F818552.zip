Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: e6687f14-e369-454b-a9be-aecdc9ee15b6, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-10T21:43:41+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 10939890_AUS_KM3054-1:26305451_AUS_10939890_KM3054-1, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 916 mm; Height: 53 mm; Depth: 526 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, z_Miele_Design_Zinc_Steel, z_Miele_Design_Cast_Grey, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Connection_Gas, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - Reference: 26305451_AUS_10939890_KM3054-1; sets with these values: 2

# IfcDistributionPort, Port_363867_1
Description: Flow; FlowDirection: SOURCEANDSINK
